
const int right_clk = 2;      //For rotating Right Motor in Clockwise Direction
const int right_aclk = 13;     //For rotating Right Motor in Anti-Clockwise Direction
const int left_clk = 8 ;       //For rotating Left Motor in Clockwise Direction
const int left_aclk = 10;       //For rotating Left Motor in Anti-Clockwise Direction
const int right_enable = 11;   //For Enabling Right Motor
const int left_enable =  3;    //For Enabling Left Motor
char ch;
bool flag;

void forward()                 //Function to move forward
{
  digitalWrite(right_clk, HIGH);
  digitalWrite(right_aclk, LOW);
  digitalWrite(left_clk, HIGH);
  digitalWrite(left_aclk, LOW);
  delay(10);

}
void right()                   //Function to move forward
{
  digitalWrite(right_clk, LOW);
  digitalWrite(right_aclk, LOW);
  digitalWrite(left_clk, HIGH);
  digitalWrite(left_aclk, LOW);
  delay(10);
}
void left()                    //Function to move Left
{
  digitalWrite(right_clk, HIGH);
  digitalWrite(right_aclk, LOW);
  digitalWrite(left_clk, LOW);
  digitalWrite(left_aclk, LOW);
  delay(10);
}
void uturn()                   //Function to move Around
{
  digitalWrite(right_clk, LOW);
  digitalWrite(right_aclk, LOW);
  digitalWrite(left_clk, HIGH);
  digitalWrite(left_aclk, LOW);
  delay(400);
}
void back()                   //Function to move Around
{
  digitalWrite(right_clk, LOW);
  digitalWrite(right_aclk, HIGH);
  digitalWrite(left_clk, LOW);
  digitalWrite(left_aclk, HIGH);
  delay(10);
}

void stopp()                   //Function to stop
{
  digitalWrite(right_clk, LOW);
  digitalWrite(right_aclk, LOW);
  digitalWrite(left_clk, LOW);
  digitalWrite(left_aclk, LOW);
  delay(10);
}

void setup() {
  Serial.begin(9600);//For starting Serial Communication
  pinMode(right_clk, OUTPUT);
  pinMode(right_aclk, OUTPUT);
  pinMode(left_clk, OUTPUT);
  pinMode(left_aclk, OUTPUT);
  pinMode(right_enable, OUTPUT);
  pinMode(left_enable, OUTPUT);
  digitalWrite(right_enable, 1);
  digitalWrite(left_enable, 1);
}

void loop() {
  ch=Serial.read();
  Serial.println(ch);
 switch(ch)
 {
   case 'w':
             flag=true;
             while(flag=true)
             {
             forward();
            char chr=Serial.read();
            Serial.println(chr);
             if(chr=='t')
             break;
             
             }
             break;
   case 'd':
             flag=true;
             while(flag=true)
             {
             left();
             ch=Serial.read();
             if(ch=='t')
             break;
             }
             break;
   case 'a':
             flag=true;
             while(flag=true)
             {
             right();
             ch=Serial.read();
             if(ch=='t')
             break;
             }
             break;
   case 's':
             flag=true;
             while(flag=true)
             {
             back();
             ch=Serial.read();
             if(ch=='t')
             break;
             }
             break; 
   default : stopp();

                                                    
 }
}
